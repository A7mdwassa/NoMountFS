## src/Kconfig
```kconfig
config NOMOUNT_FS
	tristate "NoMountFS filesystem support"
	help
	  A stackable filesystem for Android content redirection.
```
